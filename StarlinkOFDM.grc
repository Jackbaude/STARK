options:
  parameters:
    generate_options: qt_gui
    id: StarlinkOFDM
    output_language: python
    title: Starlink OFDM
  states: {}

blocks:
- name: center
  id: variable
  parameters:
    value: '1145000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/LNBMeasurements.bin
    offset: '100'
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '8192'
    grid: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
