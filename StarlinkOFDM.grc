options:
  parameters:
    generate_options: qt_gui
    id: StarlinkOFDM
    output_language: python
    title: Starlink OFDM
  states: {}

blocks:
- name: center
  id: variable
  parameters:
    value: '1145000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/mutli-band-measurements.bin
    offset: '100'
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1.0700e+10'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1.0825e+10'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1.0950e+10'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1.1075e+10'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1.1200e+10'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1.1325e+10'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_4_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1.1450e+10'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_4_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1.1575e+10'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '8192'
    grid: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_2, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_3, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_4, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_4_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_4_0_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
