options:
  parameters:
    generate_options: qt_gui
    id: StarlinkOFDM
    output_language: python
    title: Starlink OFDM
  states: {}

blocks:
- name: center
  id: variable
  parameters:
    value: '15750000'
  states: {}
- name: fft
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '56000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_10.8e9_with_traffic_output.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_10.7e9_with_traffic_output.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_10.9e9_with_traffic_output.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_1
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_11.1e9_with_traffic_output.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_1_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_11.0e9_with_traffic_output.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_1_0_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/output11325e9.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_1_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/output11325e9.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_1_0_1
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_11.3e9_with_traffic_output.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_1_0_1_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_11.5e9_with_traffic_output.bin
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft
    name: '"10.8e9"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft
    name: '"10.7e9"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft
    name: '"10.9e9"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft
    name: '"11.1e9"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft
    name: '"11.0e9"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft
    name: '"111325"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft
    name: '"11.3e9"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft
    name: '"11.5e9"'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-52'
    name: '"10.8e9"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-52'
    name: '"10.7e9"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-52'
    name: '"10.9e9"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-52'
    name: '"11.1e9"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-52'
    name: '"11.0e9"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-52'
    name: '"11325"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-52'
    name: '"11.3e9"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    int_min: '-52'
    name: '"11.5e9"'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_file_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_file_source_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_file_source_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_file_source_0_0_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_file_source_0_0_1, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [blocks_file_source_0_0_1_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [blocks_file_source_0_0_1_0, '0', qtgui_waterfall_sink_x_0_0_1_0, '0']
- [blocks_file_source_0_0_1_0_0, '0', qtgui_freq_sink_x_0_0_1_0_0, '0']
- [blocks_file_source_0_0_1_0_0, '0', qtgui_waterfall_sink_x_0_0_1_0_0, '0']
- [blocks_file_source_0_0_1_0_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0_0_1_0_1, '0', qtgui_freq_sink_x_0_0_1_0_1, '0']
- [blocks_file_source_0_0_1_0_1, '0', qtgui_waterfall_sink_x_0_0_1_0_1, '0']
- [blocks_file_source_0_0_1_0_1_0, '0', qtgui_freq_sink_x_0_0_1_0_1_0, '0']
- [blocks_file_source_0_0_1_0_1_0, '0', qtgui_waterfall_sink_x_0_0_1_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
