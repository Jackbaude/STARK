options:
  parameters:
    generate_options: qt_gui
    id: StarlinkOFDM
    output_language: python
    title: Starlink OFDM
  states: {}

blocks:
- name: center
  id: variable
  parameters:
    value: '1.825e+9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '56000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_11.2e9_output.bin
    offset: '100'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/jakku/git/STARK/data/A_11.2e9_with_traffic_output.bin
    offset: '100'
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_4_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '32768'
    name: '"Without Traffic"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_4_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '32768'
    name: '"With Traffic"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '32768'
    grid: 'True'
    name: '"Without Traffic"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center
    fftsize: '32768'
    grid: 'True'
    name: '"With Traffic"'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_4_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_file_source_0_0, '0', qtgui_freq_sink_x_0_4_0_0, '0']
- [blocks_file_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
